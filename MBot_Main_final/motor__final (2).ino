void forward() {
  leftMotor.run(-SPEED * 0.97);
  rightMotor.run(SPEED);
}

//Turn Functions for Obstacle Avoidance
void adjustRight() {
  leftMotor.run(-SPEED);
  rightMotor.run(ADJUST_SPEED);
  delay(ADJUST_DELAY);
}

void adjustLeft() {
  leftMotor.run(-ADJUST_SPEED);
  rightMotor.run(SPEED);
  delay(ADJUST_DELAY);
}

void stop(int time) {
  leftMotor.stop();
  rightMotor.stop();
  delay(time);
}

void moveOneBox(int time) {
  stop(FORWARD_DELAY);
  leftMotor.run(-SPEED);
  rightMotor.run(SPEED);
  delay(time);
  stop(FORWARD_DELAY);
}

void turnRight(int degree) {
  leftMotor.run(-SPEED); // Left wheel goes anti-clockwise
  rightMotor.run(-SPEED); //right wheel goes anti-clockwise
  delay(TURN_DELAY_right / 90 * degree); 
}

void turnLeft(int degree) {
  leftMotor.run(SPEED);
  rightMotor.run(SPEED);
  delay(TURN_DELAY_left / 90 * degree);
}

void uTurn() {
  for (int i = 0; i < 2; i++) {
    if (ultra_distance > 10) turnLeft(150);
    else turnRight(150);
    stop(100);
  }
}

void twoLeftTurn() {
  turnLeft(150);
  moveOneBox(ONEBOX_DELAY);
  turnLeft(150);
}

void twoRightTurn() {
  turnRight(150);
  moveOneBox(ONEBOX_DELAY);
  turnRight(150);
}

//Indefinite loop
void stopIndef() {
  leftMotor.stop();
  rightMotor.stop();
  while(true)
  {
    delay(10);
  }
}
